# Keil uVision project 重写.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 重写 +hex
  c flags: Optimize=9 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 lcd12864.c ds1302.c main.c word.c lunar_calendar.c keyscan.c myutils.c dth11.c mp3.c yanwubaojing.c
